options:
  parameters:
    author: aruncs
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: int(48e3)
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: int(192e3)
    tau: '75e-6'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/aruncs/Music/chammak.wav
    repeat: 'True'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(100e6)
    samplerate: int(1e6)
    type: fc32
    uri: 192.168.2.1
  states: {}

connections:
- [analog_wfm_tx_0, '0', iio_pluto_sink_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
