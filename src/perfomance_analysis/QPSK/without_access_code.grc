options:
  parameters:
    author: aruncs
    generate_options: qt_gui
    id: without_access_codes
    output_language: python
    title: IWhtout kk
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '"1110000101011010111010001001001111100001010110101110100010010011"'
  states: {}
- name: ber_calc_delay
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '1000'
    value: '1'
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    npwr: '1'
    precision: '8'
    type: qpsk
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.50'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '20000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: '1.040'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: InFile
  id: parameter
  parameters:
    label: File Name
    type: str
    value: default
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '5'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '800'
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ./output.tmp
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/aruncs/Git/Design-and-Implementation-of-Software-Defined-Radio-in-5Ghz-Communication/src/perfomance_analysis/QPSK/message_2.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '60'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: usrp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"1110000101011010111010001001001111100001010110101110100010010011"'
    tagname: packet_len
    threshold: '1'
    type: byte
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    use_snr: 'True'
    w: phase_bw
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {state: disabled}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '16'
    sps: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    FileName: '"/home/aruncs/Projects/Design-and-Implementation-of-Software-Defined-Radio-in-5Ghz-Communication/src/QPSK/message.txt"'
    Pkt_len: '60'
    _source_code: |
      """
      Embedded Python Block: File Source to Tagged Stream
      """

      import numpy as np
      from gnuradio import gr
      import time
      import pmt
      import os.path
      import sys
      import base64

      """
      State definitions
          0   idle
          1   send preamble
          2   send file data
          3   send file name
          4   send post filler
      """
      class blk(gr.sync_block):
          def __init__(self, FileName='None', Pkt_len=52):
              gr.sync_block.__init__(
                  self,
                  name='EPB: File Source to Tagged Stream',
                  in_sig=None,
                  out_sig=[np.uint8])
              self.FileName = FileName
              self.Pkt_len = Pkt_len
              self.state = 0      # idle state
              self.pre_count = 0
              self.indx = 0
              self._debug = 0     
              self.data = ""
              self.transmission_complete = False  # New flag to track completion

              if (os.path.exists(self.FileName)):
                  self.f_in = open(self.FileName, 'rb')
                  self._eof = False
                  if (self._debug):
                      print("File name:", self.FileName)
                  self.state = 1  # Start with preamble
              else:
                  print(self.FileName, 'does not exist')
                  self._eof = True
                  self.state = 0

              # Preamble and filler definitions (unchanged)
              self.char_list = [37,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,93]
              self.c_len = len(self.char_list)
              self.filler = [37,85,85,85, 35,69,79,70, 85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,93]
              self.f_len = len(self.filler)

          def work(self, input_items, output_items):
              if self.transmission_complete:
                  return 0  # Stay idle after transmission

              if (self.state == 0):
                  return 0  # Idle

              elif (self.state == 1):
                  # Send preamble (ONCE)
                  key1 = pmt.intern("packet_len")
                  val1 = pmt.from_long(self.c_len)
                  self.add_item_tag(0, self.indx, key1, val1)
                  self.indx += self.c_len
                  for i in range(self.c_len):
                      output_items[0][i] = self.char_list[i]
                  self.state = 2  # Move to file data
                  return self.c_len

              elif (self.state == 2):
                  # Send file data (ONCE per chunk)
                  buff = self.f_in.read(self.Pkt_len)
                  b_len = len(buff)
                  if b_len == 0:
                      self._eof = True
                      self.f_in.close()
                      self.state = 3  # Send filename
                      return 0
                  encoded = base64.b64encode(buff)
                  e_len = len(encoded)
                  key0 = pmt.intern("packet_len")
                  val0 = pmt.from_long(e_len)
                  self.add_item_tag(0, self.indx, key0, val0)
                  self.indx += e_len
                  for i in range(e_len):
                      output_items[0][i] = encoded[i]
                  return e_len

              elif (self.state == 3):
                  # Send filename (ONCE)
                  fn_len = len(self.FileName)
                  key1 = pmt.intern("packet_len")
                  val1 = pmt.from_long(fn_len + 8)
                  self.add_item_tag(0, self.indx, key1, val1)
                  self.indx += (fn_len + 8)
                  # Fill first 8 bytes with filler
                  for i in range(8):
                      output_items[0][i] = self.filler[i]
                  # Append filename
                  for j, char in enumerate(self.FileName):
                      output_items[0][8 + j] = ord(char)
                  self.state = 4
                  return fn_len + 8

              elif (self.state == 4):
                  # Send post-filler (ONCE)
                  key1 = pmt.intern("packet_len")
                  val1 = pmt.from_long(self.f_len)
                  self.add_item_tag(0, self.indx, key1, val1)
                  self.indx += self.f_len
                  for i in range(self.f_len):
                      output_items[0][i] = self.filler[i]
                  self.transmission_complete = True  # Mark transmission as complete
                  return self.f_len

              return 0
  states: {state: disabled}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: fft_filter_xxx_0_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(5e9)
    samplerate: usrp_rate
    type: fc32
    uri: 192.168.2.1
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(5e9)
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: usrp_rate
    type: fc32
    uri: 192.168.2.1
  states: {state: disabled}
- name: mmse_resampler_xx_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 1.0/((usrp_rate/samp_rate)*rs_ratio)
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    comment: 0,2,1,2
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: 0,0,1,2
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,2
    type: complex
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,2,1,2
    label1: ''
    name: Correlate Output
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: 1,0,1,2
    gui_hint: 1,0,1,2
    label1: ''
    name: Correlate input
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.2'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_0_2_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: 1,0,1,2
    label1: ''
    name: demod bits
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.2'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Transmitted Wave"'
    size: '1024'
    srate: samp_rate
    type: complex
    ylabel: '"Amplitude"'
    yunit: '"Time"'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: (int)(usrp_rate/samp_rate)
    interp: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_wave
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: r1
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: transmitted_
  states: {state: disabled}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: source_data
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: received_data
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: t1
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: tx_wave
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: r1
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: transmitted_
  states: {state: disabled}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: source_data
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: received_data
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49210
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49210
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_delay_0, '0', fec_ber_bf_0, '0']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_file_source_0, '0', virtual_sink_0_0, '0']
- [blocks_file_source_0, '0', virtual_sink_2, '0']
- [blocks_repack_bits_bb_1_0, '0', blocks_file_sink_0, '0']
- [blocks_repack_bits_bb_1_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', virtual_sink_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', virtual_sink_2, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_throttle2_0, '0', virtual_sink_0, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_uchar_to_float_0_0_1, '0', qtgui_time_sink_x_0_2_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_repack_bits_bb_1_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_uchar_to_float_0_0_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_3, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0_0, '0', fft_filter_xxx_0_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_file_sink_0, '0']
- [digital_diff_decoder_bb_0, '0', virtual_sink_0_0_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_linear_equalizer_0, '0', virtual_sink_0_1, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [epy_block_0, '0', digital_crc32_bb_0, '0']
- [epy_block_0, '0', virtual_sink_2, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']
- [fft_filter_xxx_0_0_0_0, '0', mmse_resampler_xx_0_0, '0']
- [iio_pluto_source_0, '0', rational_resampler_xxx_0, '0']
- [mmse_resampler_xx_0_0, '0', blocks_throttle2_0, '0']
- [rational_resampler_xxx_0, '0', analog_agc_xx_0, '0']
- [virtual_source_0, '0', digital_costas_loop_cc_0, '0']
- [virtual_source_1, '0', digital_constellation_modulator_0_0, '0']
- [virtual_source_2, '0', iio_pluto_sink_0, '0']
- [virtual_source_2, '0', virtual_sink_1, '0']
- [virtual_source_2, '0', zeromq_pub_sink_0_0, '0']
- [virtual_source_2_0, '0', blocks_uchar_to_float_0_0, '0']
- [virtual_source_2_0, '0', digital_map_bb_0, '0']
- [virtual_source_3, '0', rational_resampler_xxx_0, '0']
- [virtual_source_4, '0', blocks_delay_0, '0']
- [virtual_source_5, '0', fec_ber_bf_0, '1']
- [zeromq_sub_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
