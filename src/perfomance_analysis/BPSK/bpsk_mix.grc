options:
  parameters:
    author: aruncs
    generate_options: qt_gui
    id: bpsk_mix
    output_language: python
    title: BPSK MIX
  states: {}

blocks:
- name: MTU
  id: variable
  parameters:
    value: '1500'
  states: {}
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    npwr: '1'
    precision: '8'
    type: bpsk
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: excess_bw_0
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '20000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: '1.040'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX GAIN
    rangeType: int
    start: '1'
    step: '1'
    stop: '70'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '2.0'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: data/output.tmp
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: data/tx_data.bin
    type: byte
  states: {}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: data/demod_bits.bin
    type: byte
  states: {}
- name: blocks_file_sink_1_0_0
  id: blocks_file_sink
  parameters:
    file: data/after_correlate_access.bin
    type: byte
  states: {}
- name: blocks_file_sink_1_0_0_0
  id: blocks_file_sink
  parameters:
    file: data/after_repack.bin
    type: byte
  states: {}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: data/rx_bits.bin
    type: byte
  states: {}
- name: blocks_file_sink_3
  id: blocks_file_sink
  parameters:
    file: data/tx_source.bin
    type: byte
  states: {}
- name: blocks_file_sink_3_0
  id: blocks_file_sink
  parameters:
    file: data/tx_after_crc.bin
    type: byte
  states: {}
- name: blocks_file_sink_3_0_0
  id: blocks_file_sink
  parameters:
    file: data/tx_bits.bin
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
    log_level: trace
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: De
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: usrp_rate
    type: complex
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_1_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: bypassed}
- name: blocks_throttle2_1_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: bypassed}
- name: blocks_throttle2_1_2
  id: blocks_throttle2
  parameters:
    samples_per_second: usrp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_2
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1'
    freq_offset: '0.01'
    noise_voltage: '0.316'
    seed: '0'
    taps: '[1.0+0j]'
  states: {state: bypassed}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: phase_bw
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'False'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '44'
    rolloff: excess_bw
    samps_per_sym: sps
    type: cc
    w: phase_bw
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1]'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    FileName: '"message.txt"'
    Pkt_len: '52'
    _source_code: "\"\"\"\nEmbedded Python Block: File Source to Tagged Stream\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport pmt\nimport os.path\nimport sys\nimport base64\n\n\"\"\"\nState definitions\n    0   idle\n    1   send preamble\n    2   send file data\n    3   send file name\n    4   send post filler\n\"\"\"\n\nclass blk(gr.sync_block):\n    def __init__(self, FileName='None', Pkt_len=52):\n        gr.sync_block.__init__(\n            self,\n            name='EPB: File Source to Tagged Stream',\n            in_sig=None,\n            out_sig=[np.uint8])\n        self.FileName = FileName\n        self.Pkt_len = Pkt_len\n        self.state = 0      # idle state\n        self.pre_count = 0\n        self.indx = 0\n        self._debug = 0     # debug\n        self.data = \"\"\n\n        if (os.path.exists(self.FileName)):\n            # open input file\n            self.f_in = open (self.FileName, 'rb')\n            self._eof = False\n            if (self._debug):\n                print (\"File name:\", self.FileName)\n            self.state = 1\n        else:\n            print(self.FileName, 'does not exist')\n            self._eof = True\n            self.state = 0\n\n        self.char_list = [37,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,93]\n        self.c_len = len (self.char_list)\n        # print (self.c_len)\n        self.filler = [37,85,85,85, 35,69,79,70, 85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,93]\n        self.f_len = len (self.filler)\n\n    def work(self, input_items, output_items):\n\n        if (self.state == 0):\n            # idle\n            return (0)\n\n        elif (self.state == 1):\n            # send preamble\n            if (self._debug):\n                print (\"state = 1\", self.pre_count)\n            key1 = pmt.intern(\"packet_len\")\n            val1 = pmt.from_long(self.c_len)\n            self.add_item_tag(0, # Write to output port 0\n                self.indx,   # Index of the tag\n                key1,   # Key of the tag\n                val1    # Value of the tag\n                )\n            self.indx += self.c_len\n            i = 0\n            while (i < self.c_len):\n                output_items[0][i] = self.char_list[i]\n                i += 1\n            self.pre_count += 1\n            if (self.pre_count > 64):\n                self.pre_count = 0\n                self.state = 2      # send msg\n            return (self.c_len)\n\n        elif (self.state == 2):\n            while (not (self._eof)):\n                buff = self.f_in.read(self.Pkt_len)\n                b_len = len(buff)\n                if b_len == 0:\n                    print ('End of file')\n                    self._eof = True\n                    self.f_in.close()\n                    self.state = 3      # send file name\n                    self.pre_count = 0\n                    break\n                # convert to Base64\n                encoded = base64.b64encode(buff)\n                e_len = len(encoded)\n                if (self._debug):\n                    print ('b64 length =', e_len)\n                key0 = pmt.intern(\"packet_len\")\n                val0 = pmt.from_long(e_len)\n                self.add_item_tag(0, # Write to output port 0\n                    self.indx,   # Index of the tag\n                    key0,   # Key of the tag\n                    val0    # Value of the tag\n                    )\n                self.indx += e_len\n                i = 0\n                while (i < e_len):\n                    output_items[0][i] = encoded[i]\n                    i += 1\n                return (e_len)\n\n        elif (self.state == 3):\n            # send file name\n            fn_len = len (self.FileName)\n            key1 = pmt.intern(\"packet_len\")\n            val1 = pmt.from_long(fn_len+8)\n            self.add_item_tag(0, # Write to output port 0\n                self.indx,   # Index of the tag\n                key1,   # Key of the tag\n                val1    # Value of the tag\n                )\n            self.indx += (fn_len+8)\n            i = 0\n            while (i < 8):\n                output_items[0][i] = self.filler[i]\n                i += 1\n            j = 0\n            while (i < (fn_len+8)):\n                output_items[0][i] = ord(self.FileName[j])\n                i += 1\n                j += 1\n            self.state = 4\n            return (fn_len+8)\n\n        elif (self.state == 4):\n            # send post filler\n            if (self._debug):\n                print (\"state = 4\", self.pre_count)\n            key1 = pmt.intern(\"packet_len\")\n            val1 = pmt.from_long(self.f_len)\n            self.add_item_tag(0, # Write to output port 0\n                self.indx,   # Index of the tag\n                key1,   # Key of the tag\n                val1    # Value of the tag\n                )\n            self.indx += self.f_len\n            i = 0\n            while (i < self.f_len):\n                output_items[0][i] = self.filler[i]\n                i += 1\n            self.pre_count += 1\n            if (self.pre_count > 16):\n                self.pre_count = 0\n                self.state = 0      # idle\n            return (self.f_len)\n\n        return (0)\n\n"
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Custom Looping Number Source',
                  in_sig=None,
                  out_sig=[np.uint8]
              )
              self.state = 0       # 0: send preamble, 1: send numbers, 2: send EOF
              self.numbers = list(range(1, 11))  # Numbers 1 to 10
              self.preamble = [ord('%'), ord('U'), ord('U'), ord(']')]  # % U U ]
              self.eof_marker = [ord('#'), ord('E'), ord('O'), ord('F')]  # "#EOF"
              self.index = 0

          def work(self, input_items, output_items):
              out = output_items[0]
              produced = 0

              while produced < len(out):
                  if self.state == 0:
                      # Send preamble "UUUU" (state 0)
                      remaining_preamble = min(len(self.preamble), len(out) - produced)
                      if remaining_preamble > 0:
                          out[produced:produced+remaining_preamble] = self.preamble[:remaining_preamble]
                          # Add packet_len tag (total length of preamble + numbers + EOF)
                          key = pmt.intern("packet_len")
                          val = pmt.from_long(len(self.preamble) + len(self.numbers) + len(self.eof_marker))
                          self.add_item_tag(0, self.nitems_written(0) + produced, key, val)
                          produced += remaining_preamble
                          if remaining_preamble == len(self.preamble):
                              self.state = 1  # Transition to numbers state

                  elif self.state == 1:
                      # Send numbers 1-10 (state 1)
                      if self.index < len(self.numbers):
                          out[produced] = self.numbers[self.index]
                          produced += 1
                          self.index += 1
                          if self.index == len(self.numbers):
                              self.state = 2  # Transition to EOF state

                  elif self.state == 2:
                      # Send EOF marker "#EOF" (state 2)
                      remaining_eof = min(len(self.eof_marker), len(out) - produced)
                      if remaining_eof > 0:
                          out[produced:produced+remaining_eof] = self.eof_marker[:remaining_eof]
                          produced += remaining_eof
                          if remaining_eof == len(self.eof_marker):
                              self.state = 0  # Reset to preamble state
                              self.index = 0  # Reset numbers index

              return produced
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import time
      import os

      class blk(gr.sync_block):
          """
          Stream-Based BER Calculator with Logging and Live Average
          """
          def __init__(self, reference_bits_path="tx_bits.bin", log_file_path="ber_log.csv"):
              gr.sync_block.__init__(
                  self,
                  name='Enhanced BER Calculator',
                  in_sig=[np.uint8],
                  out_sig=None
              )

              # Reference bits
              self.reference_bits_path = reference_bits_path
              self.ref_bits = self._load_reference_bits(reference_bits_path)
              self.offset = 0

              # Packet processing
              self.current_packet_len = None
              self.current_packet_data = []

              # Logging and stats
              self.log_file_path = log_file_path
              self.packet_count = 0
              self.total_errors = 0
              self.total_bits = 0

              # Output port for live BER
              self.message_port_register_out(pmt.intern("ber_out"))

              # Prepare CSV
              self._init_log_file()

          def _load_reference_bits(self, path):
              try:
                  with open(path, "rb") as f:
                      print(f"[+] Loading reference bits from: {path}")
                      return np.unpackbits(np.frombuffer(f.read(), dtype=np.uint8))
              except FileNotFoundError:
                  print(f"[!] Reference bits file not found: {path}")
                  return np.array([], dtype=np.uint8)

          def _init_log_file(self):
              # Add header if file is new
              if not os.path.exists(self.log_file_path):
                  with open(self.log_file_path, "w") as f:
                      f.write("timestamp,packet_number,packet_len,errors,ber,avg_ber\n")

          def work(self, input_items, output_items):
              inp = input_items[0]
              nread = self.nitems_read(0)

              for i in range(len(inp)):
                  tags = self.get_tags_in_range(0, nread + i, nread + i + 1)
                  for tag in tags:
                      if pmt.symbol_to_string(tag.key) == "packet_len":
                          self.current_packet_len = pmt.to_long(tag.value)
                          self.current_packet_data = []

                  if self.current_packet_len is not None:
                      self.current_packet_data.append(inp[i])

                      if len(self.current_packet_data) == self.current_packet_len:
                          rx_bits = np.array(self.current_packet_data, dtype=np.uint8)
                          ref_bits = self.ref_bits[self.offset:self.offset + self.current_packet_len]

                          if len(ref_bits) != self.current_packet_len:
                              print("[!] Reference bits mismatch, skipping")
                          else:
                              errors = np.sum(rx_bits != ref_bits)
                              ber = errors / self.current_packet_len
                              self.total_errors += errors
                              self.total_bits += self.current_packet_len
                              self.packet_count += 1
                              avg_ber = self.total_errors / self.total_bits

                              # Print to console
                              print(f"[BER] Packet #{self.packet_count} → Errors: {errors} / {self.current_packet_len} → BER: {ber:.6f}, Avg: {avg_ber:.6f}")

                              # Log to CSV
                              timestamp = time.time()
                              with open(self.log_file_path, "a") as f:
                                  f.write(f"{timestamp},{self.packet_count},{self.current_packet_len},{errors},{ber:.6f},{avg_ber:.6f}\n")

                              # Send BER via message port
                              msg = pmt.from_double(ber)
                              self.message_port_pub(pmt.intern("ber_out"), msg)

                          self.offset += self.current_packet_len
                          self.current_packet_len = None
                          self.current_packet_data = []

              return len(inp)
    log_file_path: '"data/ber_log.csv"'
    reference_bits_path: '"data/tx_bits.bin"'
  states: {}
- name: epy_block_2_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # Embedded Python Block
          """
          Stream-Based BER Calculator
          """
          def __init__(self, reference_bits_path="tx_bits.bin"):
              gr.sync_block.__init__(
                  self,
                  name='Stream-Based BER Calculator',
                  in_sig=[np.uint8],
                  out_sig=None
              )

              # Parameters
              self.reference_bits_path = reference_bits_path
              self.ref_bits = self._load_reference_bits(reference_bits_path)
              self.offset = 0  # Current position in ref_bits
              self.current_packet_len = None
              self.current_packet_data = []

          def _load_reference_bits(self, path):
              try:
                  with open(path, "rb") as f:
                      print(f"[+] Loading reference bits from: {path}")
                      return np.unpackbits(np.frombuffer(f.read(), dtype=np.uint8))
              except FileNotFoundError:
                  print(f"[!] Reference bits file not found: {path}")
                  return np.array([], dtype=np.uint8)

          def set_reference_bits_path(self, path):
              """Set a new reference bits file path and reload the bits."""
              self.reference_bits_path = path
              self.ref_bits = self._load_reference_bits(path)
              self.offset = 0  # Reset offset

          def work(self, input_items, output_items):
              inp = input_items[0]
              nread = self.nitems_read(0)
              produced = 0

              for i in range(len(inp)):
                  # Check for packet_len tag
                  tags = self.get_tags_in_range(0, nread + i, nread + i + 1)
                  for tag in tags:
                      if pmt.symbol_to_string(tag.key) == "packet_len":
                          print(tag.value)
                          self.current_packet_len = pmt.to_long(tag.value)
                          self.current_packet_data = []

                  # Collect data for current packet
                  if self.current_packet_len is not None:
                      self.current_packet_data.append(inp[i])

                      if len(self.current_packet_data) == self.current_packet_len:
                          # Compare with reference bits
                          rx_bits = np.array(self.current_packet_data, dtype=np.uint8)
                          ref_bits = self.ref_bits[self.offset:self.offset + self.current_packet_len]

                          if len(ref_bits) != self.current_packet_len:
                              print("[!] Reference bits too short or length mismatch, skipping")
                          else:
                              errors = np.sum(rx_bits != ref_bits)
                              ber = errors / self.current_packet_len
                              print(f"[BER] Packet Errors: {errors} / {self.current_packet_len} → BER: {ber:.6f}")

                          # Advance reference offset
                          self.offset += self.current_packet_len
                          self.current_packet_len = None
                          self.current_packet_data = []

              return len(inp)
    reference_bits_path: '"tx_bits.bin"'
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import os

      class blk(gr.sync_block):  # Embedded Python Block
          """
          SNR Estimator per Packet (logs to file)
          """
          def __init__(self, reference_bits_path="tx_bits.bin", log_file="snr_log.txt"):
              gr.sync_block.__init__(
                  self,
                  name='SNR Estimator',
                  in_sig=[np.uint8],
                  out_sig=None
              )

              self.ref_bits = self._load_reference_bits(reference_bits_path)
              self.offset = 0
              self.current_packet_len = None
              self.current_packet_data = []
              self.log_file = log_file

              with open(self.log_file, 'w') as f:
                  f.write("packet,snr_db\n")

          def _load_reference_bits(self, path):
              try:
                  with open(path, "rb") as f:
                      print(f"[+] Loading reference bits from: {path}")
                      return 2 * np.unpackbits(np.frombuffer(f.read(), dtype=np.uint8)) - 1
              except FileNotFoundError:
                  print(f"[!] Reference bits file not found: {path}")
                  return np.array([], dtype=np.int8)

          def work(self, input_items, output_items):
              inp = input_items[0]
              nread = self.nitems_read(0)

              for i in range(len(inp)):
                  # Check for packet_len tag
                  tags = self.get_tags_in_range(0, nread + i, nread + i + 1)
                  for tag in tags:
                      if pmt.symbol_to_string(tag.key) == "packet_len":
                          self.current_packet_len = pmt.to_long(tag.value)
                          self.current_packet_data = []

                  if self.current_packet_len is not None:
                      self.current_packet_data.append(inp[i])

                      if len(self.current_packet_data) == self.current_packet_len:
                          # Estimate SNR
                          y = np.array(self.current_packet_data, dtype=np.float32)
                          x = self.ref_bits[self.offset:self.offset + self.current_packet_len]

                          if len(x) == self.current_packet_len:
                              noise = y - x
                              snr_linear = np.mean(x ** 2) / np.mean(noise ** 2)
                              snr_db = 10 * np.log10(snr_linear + 1e-10)

                              with open(self.log_file, 'a') as f:
                                  f.write(f"{self.offset // self.current_packet_len},{snr_db:.4f}\n")

                              print(f"[SNR] Packet #{self.offset // self.current_packet_len} → SNR: {snr_db:.2f} dB")

                          self.offset += self.current_packet_len
                          self.current_packet_len = None
                          self.current_packet_data = []

              return len(inp)
    log_file: '''data/snr_log.txt'''
    reference_bits_path: '''tx_bits.bin'''
  states: {}
- name: fft_filter_xxx_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(5e9)
    len_tag_key: packet_len
    samplerate: usrp_rate
    type: fc32
    uri: 192.168.2.1
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(5e9)
    gain1: '''fast_attack'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: usrp_rate
    type: fc32
    uri: 192.168.2.1
  states: {state: disabled}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 1.0/((usrp_rate/samp_rate)*rs_ratio)
    type: complex
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0,2,1,2
    name: '"Constellation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: 0,0,1,2
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,2
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,3
    entags: 'False'
    label1: ''
    name: Transmit data
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,2,1,2
    gui_hint: 1,2,1,2
    label1: ''
    name: Correlate Output
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,2
    gui_hint: 1,0,1,2
    label1: ''
    name: Correlate input
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.2'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Modulated Wave"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Before Modulation"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"After Correlate Access"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_4
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Test"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: (int)(usrp_rate/samp_rate)
    interp: '1'
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: baseband
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: for_demodulation
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: demodulated
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: modulated
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: baseband
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: t1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: for_demodulation
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: demodulated
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: modulated
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: t1
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: demodulated
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49201
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_1
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49203
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49203
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_1
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49201
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_file_sink_3_0_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_uchar_to_float_0_0_0_0, '0']
- [blocks_repack_bits_bb_1_0, '0', blocks_file_sink_1_0_0_0, '0']
- [blocks_repack_bits_bb_1_0, '0', blocks_uchar_to_float_1, '0']
- [blocks_repack_bits_bb_1_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_file_sink_1, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_tag_debug_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_0, '0']
- [blocks_throttle2_0_0, '0', iio_pluto_sink_0, '0']
- [blocks_throttle2_0_0, '0', zeromq_pub_sink_0, '0']
- [blocks_throttle2_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_1_0, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_throttle2_1_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle2_1_2, '0', qtgui_time_sink_x_1, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_throttle2_1_0, '0']
- [blocks_uchar_to_float_0_0_0, '0', blocks_throttle2_1_1, '0']
- [blocks_uchar_to_float_0_0_0_0, '0', blocks_throttle2_1, '0']
- [blocks_uchar_to_float_1, '0', qtgui_time_sink_x_3, '0']
- [blocks_uchar_to_float_2, '0', qtgui_time_sink_x_4, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_file_sink_3_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_2, '0']
- [channels_channel_model_0, '0', zeromq_pub_sink_1, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0, '0', epy_block_3, '0']
- [digital_constellation_modulator_0, '0', fft_filter_xxx_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_file_sink_1_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', epy_block_2, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_1, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_file_sink_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_map_bb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_map_bb_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [digital_map_bb_0, '0', virtual_sink_2, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [epy_block_0, '0', blocks_file_sink_3, '0']
- [epy_block_0, '0', digital_crc32_bb_0, '0']
- [epy_block_1, '0', digital_crc32_bb_0, '0']
- [epy_block_2, ber_out, blocks_message_debug_0, print]
- [fft_filter_xxx_0_0_0, '0', mmse_resampler_xx_0, '0']
- [iio_pluto_source_0, '0', rational_resampler_xxx_0, '0']
- [mmse_resampler_xx_0, '0', blocks_throttle2_0_0, '0']
- [mmse_resampler_xx_0, '0', virtual_sink_3, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle2_0, '0']
- [virtual_source_0, '0', analog_agc_xx_0, '0']
- [virtual_source_0_0, '0', blocks_repack_bits_bb_0_0, '0']
- [virtual_source_0_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_1, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_2, '0', blocks_file_sink_1_0, '0']
- [virtual_source_2, '0', blocks_uchar_to_float_0_0, '0']
- [virtual_source_2, '0', digital_correlate_access_code_xx_ts_0, '0']
- [virtual_source_3, '0', blocks_throttle2_1_2, '0']
- [virtual_source_4, '0', blocks_uchar_to_float_0, '0']
- [virtual_source_5, '0', blocks_uchar_to_float_2, '0']
- [zeromq_sub_source_0, '0', rational_resampler_xxx_0, '0']
- [zeromq_sub_source_1, '0', channels_channel_model_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
